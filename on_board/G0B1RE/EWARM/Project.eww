<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G0B1RE.ewp</path>
  </project>
  <batchBuild />
</workspace>
